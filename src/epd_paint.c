/*
 * epd_paint.c - Drawing primitives for the e-paper frame buffer. See epd_paint.h.
 */
#include "epd_paint.h"

#include <string.h>

/*
 * Classic 5x7 glyph cell, five columns per character starting at ASCII 0x20.
 * Each byte is one column; bit 0 is the top row.
 */
static const uint8_t FONT5X7[][PAINT_FONT_W] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, /*   */
    {0x00, 0x00, 0x5F, 0x00, 0x00}, /* ! */
    {0x00, 0x07, 0x00, 0x07, 0x00}, /* " */
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, /* # */
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, /* $ */
    {0x23, 0x13, 0x08, 0x64, 0x62}, /* % */
    {0x36, 0x49, 0x55, 0x22, 0x50}, /* & */
    {0x00, 0x05, 0x03, 0x00, 0x00}, /* ' */
    {0x00, 0x1C, 0x22, 0x41, 0x00}, /* ( */
    {0x00, 0x41, 0x22, 0x1C, 0x00}, /* ) */
    {0x14, 0x08, 0x3E, 0x08, 0x14}, /* * */
    {0x08, 0x08, 0x3E, 0x08, 0x08}, /* + */
    {0x00, 0x50, 0x30, 0x00, 0x00}, /* , */
    {0x08, 0x08, 0x08, 0x08, 0x08}, /* - */
    {0x00, 0x60, 0x60, 0x00, 0x00}, /* . */
    {0x20, 0x10, 0x08, 0x04, 0x02}, /* / */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* 0 */
    {0x00, 0x42, 0x7F, 0x40, 0x00}, /* 1 */
    {0x42, 0x61, 0x51, 0x49, 0x46}, /* 2 */
    {0x21, 0x41, 0x45, 0x4B, 0x31}, /* 3 */
    {0x18, 0x14, 0x12, 0x7F, 0x10}, /* 4 */
    {0x27, 0x45, 0x45, 0x45, 0x39}, /* 5 */
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, /* 6 */
    {0x01, 0x71, 0x09, 0x05, 0x03}, /* 7 */
    {0x36, 0x49, 0x49, 0x49, 0x36}, /* 8 */
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 9 */
    {0x00, 0x36, 0x36, 0x00, 0x00}, /* : */
    {0x00, 0x56, 0x36, 0x00, 0x00}, /* ; */
    {0x00, 0x08, 0x14, 0x22, 0x41}, /* < */
    {0x14, 0x14, 0x14, 0x14, 0x14}, /* = */
    {0x41, 0x22, 0x14, 0x08, 0x00}, /* > */
    {0x02, 0x01, 0x51, 0x09, 0x06}, /* ? */
    {0x32, 0x49, 0x79, 0x41, 0x3E}, /* @ */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* A */
    {0x7F, 0x49, 0x49, 0x49, 0x36}, /* B */
    {0x3E, 0x41, 0x41, 0x41, 0x22}, /* C */
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* D */
    {0x7F, 0x49, 0x49, 0x49, 0x41}, /* E */
    {0x7F, 0x09, 0x09, 0x01, 0x01}, /* F */
    {0x3E, 0x41, 0x41, 0x51, 0x32}, /* G */
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* H */
    {0x00, 0x41, 0x7F, 0x41, 0x00}, /* I */
    {0x20, 0x40, 0x41, 0x3F, 0x01}, /* J */
    {0x7F, 0x08, 0x14, 0x22, 0x41}, /* K */
    {0x7F, 0x40, 0x40, 0x40, 0x40}, /* L */
    {0x7F, 0x02, 0x04, 0x02, 0x7F}, /* M */
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, /* N */
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* O */
    {0x7F, 0x09, 0x09, 0x09, 0x06}, /* P */
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, /* Q */
    {0x7F, 0x09, 0x19, 0x29, 0x46}, /* R */
    {0x46, 0x49, 0x49, 0x49, 0x31}, /* S */
    {0x01, 0x01, 0x7F, 0x01, 0x01}, /* T */
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, /* U */
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, /* V */
    {0x7F, 0x20, 0x18, 0x20, 0x7F}, /* W */
    {0x63, 0x14, 0x08, 0x14, 0x63}, /* X */
    {0x03, 0x04, 0x78, 0x04, 0x03}, /* Y */
    {0x61, 0x51, 0x49, 0x45, 0x43}, /* Z */
    {0x00, 0x00, 0x7F, 0x41, 0x41}, /* [ */
    {0x02, 0x04, 0x08, 0x10, 0x20}, /* \ */
    {0x41, 0x41, 0x7F, 0x00, 0x00}, /* ] */
    {0x04, 0x02, 0x01, 0x02, 0x04}, /* ^ */
    {0x40, 0x40, 0x40, 0x40, 0x40}, /* _ */
    {0x00, 0x01, 0x02, 0x04, 0x00}, /* ` */
    {0x20, 0x54, 0x54, 0x54, 0x78}, /* a */
    {0x7F, 0x48, 0x44, 0x44, 0x38}, /* b */
    {0x38, 0x44, 0x44, 0x44, 0x20}, /* c */
    {0x38, 0x44, 0x44, 0x48, 0x7F}, /* d */
    {0x38, 0x54, 0x54, 0x54, 0x18}, /* e */
    {0x08, 0x7E, 0x09, 0x01, 0x02}, /* f */
    {0x08, 0x14, 0x54, 0x54, 0x3C}, /* g */
    {0x7F, 0x08, 0x04, 0x04, 0x78}, /* h */
    {0x00, 0x44, 0x7D, 0x40, 0x00}, /* i */
    {0x20, 0x40, 0x44, 0x3D, 0x00}, /* j */
    {0x00, 0x7F, 0x10, 0x28, 0x44}, /* k */
    {0x00, 0x41, 0x7F, 0x40, 0x00}, /* l */
    {0x7C, 0x04, 0x18, 0x04, 0x78}, /* m */
    {0x7C, 0x08, 0x04, 0x04, 0x78}, /* n */
    {0x38, 0x44, 0x44, 0x44, 0x38}, /* o */
    {0x7C, 0x14, 0x14, 0x14, 0x08}, /* p */
    {0x08, 0x14, 0x14, 0x18, 0x7C}, /* q */
    {0x7C, 0x08, 0x04, 0x04, 0x08}, /* r */
    {0x48, 0x54, 0x54, 0x54, 0x20}, /* s */
    {0x04, 0x3F, 0x44, 0x40, 0x20}, /* t */
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, /* u */
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, /* v */
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, /* w */
    {0x44, 0x28, 0x10, 0x28, 0x44}, /* x */
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, /* y */
    {0x44, 0x64, 0x54, 0x4C, 0x44}, /* z */
    {0x00, 0x08, 0x36, 0x41, 0x00}, /* { */
    {0x00, 0x00, 0x7F, 0x00, 0x00}, /* | */
    {0x00, 0x41, 0x36, 0x08, 0x00}, /* } */
    {0x10, 0x08, 0x08, 0x10, 0x08}, /* ~ */
};

#define FONT_FIRST 0x20
#define FONT_LAST  0x7E

void paint_clear(uint8_t *fb, epd_color_t color)
{
    memset(fb, (color << 6) | (color << 4) | (color << 2) | color, EPD_FB_SIZE);
}

void paint_pixel(uint8_t *fb, int x, int y, epd_color_t color)
{
    if (x < 0 || x >= EPD_WIDTH || y < 0 || y >= EPD_HEIGHT) {
        return;
    }

    /* Four pixels per byte, leftmost in the high bit pair. */
    size_t addr = (size_t)y * EPD_ROW_BYTES + (size_t)x / 4;
    int shift = 6 - (x % 4) * 2;

    fb[addr] = (uint8_t)((fb[addr] & ~(0x03 << shift)) | ((color & 0x03) << shift));
}

void paint_fill_rect(uint8_t *fb, int x, int y, int w, int h, epd_color_t color)
{
    for (int row = y; row < y + h; row++) {
        for (int col = x; col < x + w; col++) {
            paint_pixel(fb, col, row, color);
        }
    }
}

void paint_rect(uint8_t *fb, int x, int y, int w, int h, int thickness, epd_color_t color)
{
    if (thickness * 2 >= w || thickness * 2 >= h) {
        paint_fill_rect(fb, x, y, w, h, color);
        return;
    }

    paint_fill_rect(fb, x, y, w, thickness, color);                          /* top */
    paint_fill_rect(fb, x, y + h - thickness, w, thickness, color);          /* bottom */
    paint_fill_rect(fb, x, y, thickness, h, color);                          /* left */
    paint_fill_rect(fb, x + w - thickness, y, thickness, h, color);          /* right */
}

void paint_fill_circle(uint8_t *fb, int cx, int cy, int r, epd_color_t color)
{
    for (int dy = -r; dy <= r; dy++) {
        for (int dx = -r; dx <= r; dx++) {
            if (dx * dx + dy * dy <= r * r) {
                paint_pixel(fb, cx + dx, cy + dy, color);
            }
        }
    }
}

/* Signed area of the triangle (a,b,c), doubled -- the usual half-plane test. */
static int edge(int ax, int ay, int bx, int by, int cx, int cy)
{
    return (bx - ax) * (cy - ay) - (by - ay) * (cx - ax);
}

void paint_fill_triangle(uint8_t *fb, int x0, int y0, int x1, int y1, int x2, int y2,
                         epd_color_t color)
{
    int min_x = x0 < x1 ? (x0 < x2 ? x0 : x2) : (x1 < x2 ? x1 : x2);
    int max_x = x0 > x1 ? (x0 > x2 ? x0 : x2) : (x1 > x2 ? x1 : x2);
    int min_y = y0 < y1 ? (y0 < y2 ? y0 : y2) : (y1 < y2 ? y1 : y2);
    int max_y = y0 > y1 ? (y0 > y2 ? y0 : y2) : (y1 > y2 ? y1 : y2);

    for (int y = min_y; y <= max_y; y++) {
        for (int x = min_x; x <= max_x; x++) {
            int w0 = edge(x1, y1, x2, y2, x, y);
            int w1 = edge(x2, y2, x0, y0, x, y);
            int w2 = edge(x0, y0, x1, y1, x, y);

            /* Inside if all three have the same sign; accept either winding. */
            if ((w0 >= 0 && w1 >= 0 && w2 >= 0) || (w0 <= 0 && w1 <= 0 && w2 <= 0)) {
                paint_pixel(fb, x, y, color);
            }
        }
    }
}

static void paint_char(uint8_t *fb, int x, int y, char c, int scale, epd_color_t color)
{
    if ((unsigned char)c < FONT_FIRST || (unsigned char)c > FONT_LAST) {
        return;
    }
    const uint8_t *glyph = FONT5X7[(unsigned char)c - FONT_FIRST];

    for (int col = 0; col < PAINT_FONT_W; col++) {
        for (int row = 0; row < PAINT_FONT_H; row++) {
            if ((glyph[col] >> row) & 0x01) {
                paint_fill_rect(fb, x + col * scale, y + row * scale, scale, scale, color);
            }
        }
    }
}

int paint_text_width(const char *text, int scale)
{
    int n = (int)strlen(text);
    return n == 0 ? 0 : n * PAINT_CHAR_ADVANCE(scale) - scale;
}

void paint_text(uint8_t *fb, int x, int y, const char *text, int scale, epd_color_t color)
{
    for (const char *p = text; *p != '\0'; p++) {
        paint_char(fb, x, y, *p, scale, color);
        x += PAINT_CHAR_ADVANCE(scale);
    }
}

void paint_text_centered(uint8_t *fb, int cx, int y, const char *text, int scale,
                         epd_color_t color)
{
    paint_text(fb, cx - paint_text_width(text, scale) / 2, y, text, scale, color);
}

void paint_text_stacked(uint8_t *fb, int x, int y, const char *text, int scale,
                        epd_color_t color)
{
    for (const char *p = text; *p != '\0'; p++) {
        paint_char(fb, x, y, *p, scale, color);
        y += (PAINT_FONT_H + 1) * scale;
    }
}

int paint_text_stacked_height(const char *text, int scale)
{
    int n = (int)strlen(text);
    return n == 0 ? 0 : n * (PAINT_FONT_H + 1) * scale - scale;
}
